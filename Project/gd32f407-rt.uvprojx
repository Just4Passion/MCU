# Keil uVision project gd32f407-rt.uvprojx, settings and files
target RT-gd32f407 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f407-rt +hex
  AfterMake: cmd /C del /q ".\Objects\*.o" ".\Objects\*.d" ".\Objects\*.crf"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407,__RTTHREAD__,__CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\Libraries\CMSIS\Device\GD\GD32F407\Include;..\Libraries\CMSIS\Include;..\Libraries\GD32F4xx_standard_peripheral\Include;..\RT-Thread\libcpu\arm\cortex-m4;..\RT-Thread\include;..\User\driver;..\User\config;..\User\RT-device
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: gd32f407-rt.sct
  group Startup
    ../Libraries/CMSIS/Device/GD/GD32F407/Source/: system_gd32f4xx.c
    ../Libraries/CMSIS/Device/GD/GD32F407/Source/ARM/: startup_gd32f407.s
  group FirmwareLibs
    ../Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Kernel
    ../RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c signal.c thread.c timer.c cpu_up.c defunct.c scheduler_comm.c scheduler_up.c
  group RT-libcpu
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../RT-Thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
  group RT-klibc
    ../RT-Thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group RT-Udevice
    ../User/RT-device/: serial_dev.c usart_drv.c device.c
  group User
    ../User/: main.c
    ../User/debug_sh/: debug_entry.c
  group User/config
    ../User/config/: gd32f4xx_it.c gd32f4xx_it.h gd32f4xx_libopt.h
  group User/driver
    ../User/driver/: drv_usart.c drv_usart.h
  group User/shell
    ../User/debug_sh/: serial.c
