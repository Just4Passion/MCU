# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F207xK GD GD32F207xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F20X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\libraries\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include; ..\..\..\..\components\libc\posix\io\eventfd; applications; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\drivers\phy; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\common; ..\libraries\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include; ..\..\..\..\components\libc\posix\io\poll; ..\libraries\GD32F20x_Firmware_Library\CMSIS; ..\libraries\gd32_drivers; .; board; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F20X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c shell.c msh.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c kstdio.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Libraries
    ../libraries/GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_usart.c gd32f20x_misc.c gd32f20x_gpio.c gd32f20x_exti.c gd32f20x_rcu.c
    ../libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
