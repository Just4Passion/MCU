# Keil uVision project WD001.uvprojx, settings and files
target WD001_All (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: WD001
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Core;..\Libraries\Board\STM32\STM32407_startup\include;..\Libraries\Board\STM32\STM32407_std_periph\inc;..\User\config;..\User\kservice;..\User\kservice\bus;..\User\kservice\dev;..\User\kservice\component;..\User\kservice\timer;..\User\kservice\event;..\User\drivers;..\User\middleware;..\User\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../Doc/: ReadMe.md
  group FirmwareLib
    ../Libraries/Board/STM32/STM32407_std_periph/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Libraries/Board/STM32/STM32407_startup/src/: startup_stm32f40xx.s system_stm32f4xx.c
  group Config
    ../User/config/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Kservice
    ../User/kservice/timer/: timer_manager.c
    ../User/kservice/bus/: bus.c
    ../User/kservice/dev/: device.c
    ../User/kservice/event/: simple_event_engine.c
  group Driver
    ../User/drivers/: drv_led.c drv_gpio.c drv_key.c drv_misc_func.c
  group App
    ../User/app/: main.c
