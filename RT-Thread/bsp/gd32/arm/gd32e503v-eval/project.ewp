# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32E50X; GD32E50X_HD; __RTTHREAD__; USE_STDPERIPH_DRIVER; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: .; packages\gd32-arm-cmsis-latest\GD32E50x; board; ..\..\..\..\include; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\drivers\smp_call; ..\libraries\gd32_drivers; packages\gd32-arm-series-latest\GD32E50x\GD32E50x_standard_peripheral\Include; ..\..\..\..\components\drivers\phy; applications; packages\gd32-arm-cmsis-latest\GD32E50x\GD\GD32E50x\Include; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\finsh; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32E50X; GD32E50X_HD; __RTTHREAD__; USE_STDPERIPH_DRIVER; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh.c shell.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c kstring.c kerrno.c rt_vsnprintf_tiny.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/IAR/: startup_gd32e50x_hd.s
    packages/gd32-arm-cmsis-latest/GD32E50x/GD/GD32E50x/Source/: system_gd32e50x.c
    packages/gd32-arm-series-latest/GD32E50x/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_usart.c
