# Keil uVision project gd32f407_freertos.uvprojx, settings and files
target gd32407_freertos (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f407_freertos
  AfterMake: cmd /C del /q ".\Objects\*.o" ".\Objects\*.d" ".\Objects\*.crf"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: --C99
  c include: ..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Libraries\CMSIS\Core\CM4;..\Libraries\Board\GD32\GD32F4xx_startup\Include;..\Libraries\Board\GD32\GD32F4xx_standard_peripheral\Include;..\User\drivers;..\User\debug;..\User\config\GD\GD32F4xx;..\User\rtos_cli;..\User\middleware\mbedtls\include
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\gd32f407_freertos.sct
  group User
    ../User/: main.c md_test.c
    ../User/debug/: serial.c debug_entry.c
    ../User/rtos_cli/: rtos_cli.c rtos_cli_example.c me_rtos_cli.c
    ../User/timer/: timer_task.c timer_jitter.c
    ../User/task_notify/: task_notify.c binary_semtest.c mutex_count_semtest.c recursive_mutex.c
    ../User/task_control/: task_monitor.c task_concurrent_access_queue.c
  group FirmwareLibs
    ../Libraries/Board/GD32/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Libraries/Board/GD32/GD32F4xx_startup/Source/ARM/: startup_gd32f407.s
    ../Libraries/Board/GD32/GD32F4xx_startup/Source/: system_gd32f4xx.c
  group User/config
    ../User/config/GD/GD32F4xx/: FreeRTOSConfig.h gd32f4xx_it.c gd32f4xx_it.h gd32f4xx_libopt.h
  group User/drivers
    ../User/drivers/: drv_fwdgt.c drv_rtc.c drv_usart.c
  group User/middleware/mbedtls
    ../User/middleware/mbedtls/src/: md5.c platform_util.c sha1.c sha3.c sha256.c sha512.c ripemd160.c poly1305.c hmac_drbg.c aes.c md.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c rsa.c rsa_alt_helpers.c constant_time.c oid.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c asn1parse.c asn1write.c base64.c pem.c pk.c pk_wrap.c pkwrite.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c pkparse.c pkcs5.c pkcs12.c cipher.c cipher_wrap.c
  group User/middleware/mbedtls_test
    ../User/middleware_test/mbedtls_test/: aes_test.c common_util.c hmac_test.c md5_test.c ripemd160_test.c sha_test.c
  group FreeRTOS
    ../FreeRTOS/src/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
