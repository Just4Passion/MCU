# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F205xC GD GD32F205xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F20X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\libcpu\arm\cortex-m3; ..\..\..\..\components\libc\compilers\common\include; ..\libraries\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include; .; applications; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\finsh; ..\..\..\..\components\drivers\include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\drivers\smp_call; ..\libraries\GD32F20x_Firmware_Library\CMSIS; board; ..\libraries\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include; ..\..\..\..\include; ..\libraries\gd32_drivers; ..\..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F20X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c kstdio.c kerrno.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Libraries
    ../libraries/GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_exti.c gd32f20x_usart.c gd32f20x_rcu.c
    ../libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
