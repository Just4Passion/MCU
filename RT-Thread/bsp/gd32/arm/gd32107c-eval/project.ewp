# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F10X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\libraries\GD32F10x_Firmware_Library\CMSIS; applications; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\include; ..\..\..\..\components\finsh; ..\libraries\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\components\drivers\phy; .; board; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\..\..\components\drivers\include; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\eventfd; ..\libraries\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\libraries\gd32_drivers; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\drivers\spi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; GD32F10X_CL; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_spi.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c kstring.c rt_vsscanf.c kstdio.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Libraries
    ../libraries/GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_spi.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_exti.c gd32f10x_rcu.c gd32f10x_usart.c
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
