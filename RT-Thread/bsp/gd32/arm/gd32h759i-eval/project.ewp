# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; GD32H7XX; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..\libcpu\arm\cortex-m7; board; applications; ..\libraries\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\io\epoll; ..\libraries\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include; ..\libraries\GD32H7xx_Firmware_Library\CMSIS; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\drivers\include; ..\libraries\gd32_drivers; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\include; ..\..\..\..\components\drivers\phy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kerrno.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_misc.c gd32h7xx_syscfg.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_gpio.c gd32h7xx_exti.c gd32h7xx_usart.c
    ../libraries/GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
