# Keil uVision project TinyOS.uvprojx, settings and files
target TinyOS (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TinyOS +hex
  AfterMake: fromelf.exe --bin -o ./Bins/TinyOS.bin ./Objects/TinyOS.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD, GD32F30x_EVAL
  c misc: --C99
  c include: ..\Libraries\Board\GD32\GD32F30x_standard_peripheral\Include;..\Libraries\Board\GD32\GD32F30x_startup\Include;..\Libraries\CMSIS\Core\CM4;..\User\config\GD\GD32F30x;..\User\debug;..\User\drivers;..\User\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/Board/GD32/GD32F30x_startup/Source/: system_gd32f30x.c
    ../Libraries/Board/GD32/GD32F30x_startup/Source/ARM/: startup_gd32f30x_hd.s
  group FirmwareLibs
    ../Libraries/Board/GD32/GD32F30x_standard_peripheral/Source/: gd32f30x_usart.c gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_gpio.c gd32f30x_bkp.c gd32f30x_pmu.c gd32f30x_timer.c
  group User
    ../User/debug/: debug_entry.c
    ../User/: main.c
    ../User/breath_led/: breath_led.c
  group User/config
    ../User/config/GD/GD32F30x/: gd32f30x_it.c gd32f30x_it.h gd32f30x_libopt.h
  group User/drivers
    ../User/drivers/: drv_usart.c drv_usart.h
  group TinyOS
    ../User/system/: os_pendsv_class.c os_pendsv_TCB.c
  group User/system
    ../User/system/: system_mng.c
